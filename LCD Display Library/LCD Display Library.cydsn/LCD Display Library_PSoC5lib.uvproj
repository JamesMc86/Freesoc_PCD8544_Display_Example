# Keil uVision project LCD Display Library_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: LCD Display Library_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h SPIM.c SPIM.h SPIM_PM.c SPIM_INT.c SPIM_PVT.h LCD_Interface_aliases.h Data_CMD_Sel.c Data_CMD_Sel.h SPIM_IntClock.c SPIM_IntClock.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD_RST.c LCD_RST.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: LCD Display Library_PSoC5lib (library)
